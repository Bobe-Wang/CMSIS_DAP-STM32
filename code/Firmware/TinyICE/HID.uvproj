# Keil uVision project HID.uvproj, settings and files
target MCBSTM32 (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: HID
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\TinyICE
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./: startup_stm32f10x_md.s system_stm32f10x.c
  group Configuration
    ./: usb_config.c
  group USB HW Driver
    ./: usbd_STM32F103.c
  group Source
    ./: USBD_Demo.c usbd_user_hid.c
    ../: DAP.c JTAG_DP.c SW_DP.c
  group Library
    ./: USB_CM3.lib
